# Keil uVision project ADC_Timer_Trigger.uvprojx, settings and files
target ADC_Timer_Trigger (6240000::V6.24::ARMCLANG)
  device: M031SD2AE Nuvoton
  pack: Nuvoton.NuMicroM0_DFP.1.0.2
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) IROM2(0x00100000,0x800) IROM3(0x00200000,0x200) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: ADC_Timer_Trigger
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1
  c include: ..\..\..\..\Library\CMSIS\Core\Include;..\..\..\..\Library\Device\Nuvoton\M031\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x100000 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M031Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../../../Library/StdDriver/src/: retarget.c uart.c clk.c adc.c timer.c sys.c gpio.c
  group User
    ../: main.c
